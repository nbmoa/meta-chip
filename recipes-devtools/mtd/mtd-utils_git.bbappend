FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-mtd-remove-max-PEB-LEB-size-check.patch"
